# Keil uVision project ser2eth_project.uvproj, settings and files
target debug (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: ser2eth_debug +hex
  c flags: Optim=1 wLevel=2
  c define: CONFIG_DEBUG
  c include: .;..\..\include;..\sam7x_ser2eth;..\..\finsh;..\..\net\lwip\src\include;..\..\net\lwip\src;..\..\net\lwip\src\arch\include;..\..\net\lwip\src\include\ipv4;..\..\filesystem\dfs;..\..\filesystem\dfs\include;..\..\filesystem\dfs\filesystems\efsl\src\include;..\..\filesystem\dfs\filesystems\efsl\src\base\include;..\..\filesystem\dfs\filesystems\efsl\src\fs\vfat\include;.\lib7x256;.\ser2eth
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group ser2eth
    ./ser2eth/: application.c apptasks.c board.c cmdProc.c dev_dbgu.c dev_emac.c dev_serial.c firmupdate.c led.c settings.c startup.c apptasks.h board.h cmdproc.h dev_dbgu.h dev_emac.h dev_serial.h firmupdate.h led.h mii.h protocol.h rtconfig.h settings.h
  group Kernel
    ../../src/: clock.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c timer.c scheduler.c slab.c thread.c device.c
  group AT91SAM7X
    ../../libcpu/arm/AT91SAM7X/: interrupt.c stack.c trap.c cpu.c context_rvds.S
  group finsh
    ../../finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group LwIP
    ../../net/lwip/src/core/: dhcp.c dns.c init.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c memp.c
    ../../net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../net/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c sockets.c
    ../../net/lwip/src/netif/: etharp.c ethernetif.c loopif.c
    ../../net/lwip/src/arch/: sys_arch_init.c sys_arch.c
  group lib7x256
    ./lib7x256/: aic.c dbgu.c efc.c emac.c flashd_efc.c math.c pio.c pmc.c rstc.c tc.c usart.c aic.h assert.h at91lib.h AT91SAM7X256.h dbgu.h efc.h emac.h flashd.h math.h pio.h pmc.h rstc.h tc.h trace.h usart.h start_rvds.S
target release (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: as above
  output: ser2eth_release +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
